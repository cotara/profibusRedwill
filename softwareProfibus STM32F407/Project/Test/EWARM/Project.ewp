# IAR project Project.ewp, settings and files
configuration Olimex STM32-E407 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32_E407; USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCIncludePath2: ..; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\board\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\SDIO_fixed; ..\DS18B20; ..\EEPROM; ..\EEPROM\TM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 111t.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
    ../: system_stm32f4xx.c
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../: LED_user.c main.c profibus4.c stm32f2xx_it.c time_user.c usart_user.c
